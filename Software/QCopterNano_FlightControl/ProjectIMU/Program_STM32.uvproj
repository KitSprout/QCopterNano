# Keil uVision project Program_STM32.uvproj, settings and files
target STM32F401C (ARM-ADS)
  device: STM32F401CC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(84000000) ELITTLE
  output: STM32F401C +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F401xx, USE_STDPERIPH_DRIVER, __FPU_PRESENT=1, __FPU_USED =1, ARM_MATH_CM4, __CC_ARM
  c include: ..\;..\Libraries\CMSIS;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\src;..\Program;..\Program\Algorithms;..\Program\Dirvers;..\Program\Modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ../Libraries/CMSIS/: startup_stm32f401xc.s
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f4xx.c
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_spi.c
    ../Program/: stm32f4xx_conf.h
  group MathARM
    ../Libraries/CMSIS/MathARM/: arm_sin_f32.c arm_cos_f32.c
  group Drivers
    ../Program/Dirvers/: stm32f4_delay.c stm32f4_usart.c stm32f4_spi.c
  group Program
    ../Program/: QCopterNano.c QCopterNano_it.c QCopterNano_ctrl.c QCopterNano_transport.c
  group Module
    ../Program/Modules/: module_rs232.c module_nrf24l01.c module_imu.c module_mpu9250.c
  group Algorithm
    ../Program/Algorithms/: algorithm_string.c algorithm_moveAve.c algorithm_pid.c algorithm_ahrs.c algorithm_quaternion.c
